# Keil uVision project Project.uvprojx, settings and files
target STM32F3-Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F3-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32F3_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F3-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Drivers/BSP/STM32F3-Discovery
    ../../../../../Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c stm32f3_discovery_gyroscope.c stm32f3_discovery_accelerometer.c
  group Example/MDK-ARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/Components
    ../../../../../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
    ../../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_dma.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rcc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_spi.c stm32f3xx_hal.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_gpio.c
  group Example/USER
    ../Src/: mems.c main.c stm32f3xx_it.c
software components: CMSIS:CORE 4.3.0
