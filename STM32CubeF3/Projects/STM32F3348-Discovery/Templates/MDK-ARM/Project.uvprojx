# Keil uVision project Project.uvprojx, settings and files
target STM32F3348-Discovery (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F334C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F3348-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F334x8,USE_HAL_DRIVER,USE_STM32F3348_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F3348-Discovery;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f334x8.s
  group Drivers/BSP/STM32F3348-Discovery
    ../../../../Drivers/BSP/STM32F3348-Discovery/: stm32f3348_discovery.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_gpio.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_irda.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c.c stm32f3xx_hal_dma.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal.c stm32f3xx_hal_can.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_usart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_tsc.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_opamp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_comp.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_wwdg.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_crc.c stm32f3xx_hal_uart.c stm32f3xx_hal_smbus.c stm32f3xx_hal_adc_ex.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.1.0
