# Keil uVision project Project.uvprojx, settings and files
target STM32F3348-Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F334C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F3348-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F334x8,USE_STM32F3348_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F3348-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/MDK-ARM
    ./: startup_stm32f334x8.s
  group Example/User
    ../Src/: stm32f3xx_hal_timebase_rtc_alarm.c stm32f3xx_it.c main.c
  group Drivers/BSP/STM32F3348-Discovery
    ../../../../../../Drivers/BSP/STM32F3348-Discovery/: stm32f3348_discovery.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rtc.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
