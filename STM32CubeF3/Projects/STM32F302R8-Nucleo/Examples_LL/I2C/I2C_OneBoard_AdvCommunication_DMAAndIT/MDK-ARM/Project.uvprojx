# Keil uVision project Project.uvprojx, settings and files
target STM32F302R8-Nucleo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F302R8-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F302x8,USE_STM32F3XX_NUCLEO,__DBG_ITM
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f3xx_it.c main.c
    ./: Retarget.c Serial.c
  group Example/MDK-ARM
    ./: startup_stm32f302x8.s
  group Drivers/STM32F3xx_LL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.3.0
