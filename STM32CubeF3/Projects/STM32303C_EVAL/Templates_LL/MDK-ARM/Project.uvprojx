# Keil uVision project Project.uvprojx, settings and files
target STM32303C_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32303C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../Drivers/STM32F3xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Example/User
    ../Src/: stm32f3xx_it.c main.c
  group Drivers/STM32F3xx_LL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_dma.c stm32f3xx_ll_pwr.c stm32f3xx_ll_comp.c stm32f3xx_ll_gpio.c stm32f3xx_ll_adc.c stm32f3xx_ll_opamp.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_spi.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_usart.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_exti.c stm32f3xx_ll_tim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
software components: CMSIS:CORE 4.3.0
