# Keil uVision project Project.uvprojx, settings and files
target STM32303C_EVAL (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,USE_STM32303C_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32303C_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  group Example/User
    ../Src/: stm32f3xx_hal_msp.c stm32f3xx_it.c main.c
  group Drivers/BSP/STM32303C_EVAL
    ../../../../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_uart.c stm32f3xx_hal.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tim.c
software components: CMSIS:CORE 4.3.0
