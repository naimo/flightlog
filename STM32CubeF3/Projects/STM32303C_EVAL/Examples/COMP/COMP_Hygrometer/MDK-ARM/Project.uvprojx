# Keil uVision project Project.uvprojx, settings and files
target STM32303C_EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32303C_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32303C_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f3xx_it.c stm32f3xx_hal_msp.c main.c
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_dac_ex.c stm32f3xx_hal.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart.c stm32f3xx_hal_flash.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_dac.c stm32f3xx_hal_comp.c stm32f3xx_hal_tim.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_spi_ex.c
  group Utilities/Fonts
    ../../../../../../Utilities/Fonts/: font12.c font20.c font8.c font24.c fonts.h font16.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32303C_EVAL
    ../../../../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval_lcd.c stm32303c_eval.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
software components: CMSIS:CORE 4.1.0
