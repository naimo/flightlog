# Keil uVision project Project.uvprojx, settings and files
target STM32303C_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32303C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32303C_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32303C_EVAL;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Log;../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Example/User
    ../Src/: temperature_sensor.c audio_play.c sd.c log.c stm32f3xx_it.c joystick.c lcd.c eeprom.c main.c
  group Drivers/BSP/STM32303C_EVAL
    ../../../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval_lcd.c stm32303c_eval_tsensor.c stm32303c_eval_sd.c stm32303c_eval.c stm32303c_eval_audio.c stm32303c_eval_eeprom.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c
    ../../../../../Drivers/BSP/Components/cs42l52/: cs42l52.c
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_i2s.c stm32f3xx_hal_gpio.c stm32f3xx_hal_spi.c stm32f3xx_hal.c stm32f3xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
