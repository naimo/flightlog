# Keil uVision project Project.uvprojx, settings and files
target STM32303C_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32303C_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32303C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f3xx_it.c stm32f3xx_hal_msp.c main.c audio_sample.c
  group Drivers/BSP/Component
    ../../../../../../Drivers/BSP/Components/cs42l52/: cs42l52.c
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_dma.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_flash.c stm32f3xx_hal_cortex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2s.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_crc.c stm32f3xx_hal_rcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32303C_EVAL
    ../../../../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval_lcd.c stm32303c_eval.c stm32303c_eval_audio.c
software components: CMSIS:CORE 4.1.0
