# Keil uVision project Project.uvprojx, settings and files
target STM32303C_EVAL (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,USE_STM32303C_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32303C_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c stmCriticalSection.c tsl_user.c stm32f3xx_it.c main.c
  group Drivers/BSP/STM32303C_EVAL
    ../../../../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval.c stm32303c_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_acq.c tsl_filter.c tsl_time.c tsl_touchkey.c tsl_acq_tsc.c tsl_ecs.c tsl_dxs.c tsl_object.c tsl_globals.c tsl_linrot.c tsl.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_uart.c stm32f3xx_hal.c stm32f3xx_hal_tsc.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
