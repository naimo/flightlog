# Keil uVision project Project.uvprojx, settings and files
target STM32F303ZE-Nucleo (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303ZE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303ZE-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../Drivers/CMSIS/Include;../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F3xx_Nucleo_144
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F3xx_Nucleo_144
    ../../../../Drivers/BSP/STM32F3xx_Nucleo_144/: stm32f3xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/MDK-ARM
    ./: startup_stm32f303xe.s
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2s.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_dma.c stm32f3xx_hal_i2c.c stm32f3xx_hal_dac.c stm32f3xx_hal_irda.c stm32f3xx_hal_pcd.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_opamp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_spi_ex.c stm32f3xx_ll_fmc.c stm32f3xx_hal_flash.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_nand.c stm32f3xx_hal_wwdg.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_pccard.c stm32f3xx_hal_usart.c stm32f3xx_hal_smbus.c stm32f3xx_hal_tsc.c stm32f3xx_hal.c stm32f3xx_hal_sram.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_crc.c stm32f3xx_hal_spi.c stm32f3xx_hal_nor.c stm32f3xx_hal_can.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_comp.c stm32f3xx_hal_rcc.c stm32f3xx_hal_uart.c
  group Example/User
    ../Src/: stm32f3xx_hal_msp.c stm32f3xx_it.c main.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
