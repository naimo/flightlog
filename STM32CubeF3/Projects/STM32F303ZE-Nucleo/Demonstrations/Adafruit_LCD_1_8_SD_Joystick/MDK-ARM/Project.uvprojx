# Keil uVision project Project.uvprojx, settings and files
target STM32F303ZE-Nucleo (ARM-ADS)
  device: STM32F303ZE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303ZE-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F3xx_Nucleo_144;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Demo/MDK-ARM
    ./: startup_stm32f303xe.s
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/FatFs/Drivers
    ../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Demo/User
    ../Src/: stm32f3xx_it.c main.c fatfs_storage.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/STM32F3xx_Nucleo_144
    ../../../../../Drivers/BSP/STM32F3xx_Nucleo_144/: stm32f3xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_spi.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
software components: CMSIS:CORE 4.1.0
