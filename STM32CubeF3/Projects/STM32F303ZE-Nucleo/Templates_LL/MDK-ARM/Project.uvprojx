# Keil uVision project Project.uvprojx, settings and files
target STM32F303ZE-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303ZE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F303ZE-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xE,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../Drivers/CMSIS/Include;../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F3xx_Nucleo_144
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/MDK-ARM
    ./: startup_stm32f303xe.s
  group Example/User
    ../Src/: stm32f3xx_it.c main.c
  group Drivers/STM32F3xx_LL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_crc.c stm32f3xx_ll_opamp.c stm32f3xx_ll_rtc.c stm32f3xx_ll_exti.c stm32f3xx_ll_tim.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_spi.c stm32f3xx_ll_dac.c stm32f3xx_ll_gpio.c stm32f3xx_ll_utils.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_dma.c stm32f3xx_ll_usart.c stm32f3xx_ll_i2c.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
