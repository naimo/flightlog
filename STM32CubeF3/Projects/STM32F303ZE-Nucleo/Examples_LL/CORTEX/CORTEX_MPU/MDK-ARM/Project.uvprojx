# Keil uVision project Project.uvprojx, settings and files
target STM32F303ZE-Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303ZE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303ZE-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F303xE,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/MDK-ARM
    ./: startup_stm32f303xe.s
  group Example/User
    ../Src/: stm32f3xx_it.c main.c
  group Drivers/STM32F3xx_LL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
