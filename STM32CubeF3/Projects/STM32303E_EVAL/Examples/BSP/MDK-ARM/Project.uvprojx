# Keil uVision project Project.uvprojx, settings and files
target STM32303E_EVAL (ARM-ADS)
  device: STM32F303VE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32303E_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE,USE_STM32303E_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32303E_EVAL;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Log;../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../../Drivers/BSP/Components/cs42l52/: cs42l52.c
  group Example/MDK-ARM
    ./: startup_stm32f303xe.s
  group Doc
    ../: readme.txt
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_spi_ex.c stm32f3xx_hal.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_gpio.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_i2s.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rcc.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/User
    ../Src/: joystick.c sd.c eeprom.c lcd.c audio_play.c main.c temperature_sensor.c stm32f3xx_it.c log.c
  group Drivers/BSP/STM32303E_EVAL
    ../../../../../Drivers/BSP/STM32303E_EVAL/: stm32303e_eval.c stm32303e_eval_sd.c stm32303e_eval_lcd.c stm32303e_eval_tsensor.c stm32303e_eval_eeprom.c stm32303e_eval_audio.c
software components: CMSIS:CORE 4.3.0
